# Keil uVision project Xiaomi_CyberDog1.uvprojx, settings and files
target Xiaomi_CyberDog1 (6190000::V6.19::ARMCLANG)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Xiaomi_CyberDog1 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,ARM_MATH_CM4
  c include: ../Drivers/CMSIS/Include;../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../APP;../BSP;../MID/MID_foc_float;../MID/MID_segger_rtt;../MID/MID_foc;../MID/MID_SoftIIC/SoftIIC_Fast;../COM;../MID/MID_cm_backtrace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c iwdg.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group APP
    ../APP/: FOC_run.c FOC_run.h main_user.c main_user.h Task_function.c Task_function.h
  group BSP
    ../BSP/: AS5600.c AS5600.h CAN.c CAN.h ThreeHall.c ThreeHall.h drv83xx.c drv83xx.h drv83xx_reg.h
    ../MID/MID_SoftIIC/SoftIIC_Fast/: Soft_IIC.c Soft_IIC.h
  group MID_foc
    ../MID/MID_foc_float/: foc.c foc.h foc_pid.c foc_pid.h speed_pid.c speed_pid.h position_pid.c position_pid.h Para_identify.c Para_identify.h
    ../MID/MID_foc/: IQ_math.c IQ_math.h dead_comp.c dead_comp.h
  group MID_segger_rtt
    ../MID/MID_segger_rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_Port.c SEGGER_RTT_Port.h SEGGER_RTT_printf.c
  group COM
    ../COM/: filter.c filter.h
  group MID_cm_backtrace
    ../MID/MID_cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h cmb_fault.S
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
